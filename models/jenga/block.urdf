Commit message: clean code and models

File: models/jenga/block.urdf (robot description, URDF)
Before this commit: robot block_2, 1 links, 0 joints
Links:
- link block_2_base_link: mass 0.02 -> 1; geometry collision box size=0.075 0.025 0.015; visual box size=0.075 0.025 0.015
